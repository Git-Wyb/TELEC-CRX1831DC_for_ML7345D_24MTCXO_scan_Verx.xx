# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: D:\My Project\CRX1831DC Chang Chip ADF7030 to ML7345D\bank\24MHz Pro\TELEC-CRX1831DC_for_ML7345D_24M_scan_Verx.xx\Libraries\inc; D:\My Project\CRX1831DC Chang Chip ADF7030 to ML7345D\bank\24MHz Pro\TELEC-CRX1831DC_for_ML7345D_24M_scan_Verx.xx\radio; D:\My Project\CRX1831DC Chang Chip ADF7030 to ML7345D\bank\24MHz Pro\TELEC-CRX1831DC_for_ML7345D_24M_scan_Verx.xx\user_src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Bunka STM8L151 RX Ver.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Radio
    radio/: ML7345.c ML7345.h ML7345_defs.h ML7345_HAL.c ML7345_HAL.h
  group STM8L15x Libraries
    Libraries/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group user
    user_src/: eeprom.c ID_Decode.c Initial.c main.c ram.c spi.c stm8l15x_it.c Timer.c uart.c
